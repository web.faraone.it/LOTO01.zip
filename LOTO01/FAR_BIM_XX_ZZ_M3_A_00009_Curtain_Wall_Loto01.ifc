Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: REF_LOTO01
Time: 2017-10-05T23:02:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 05 23:02:59 2017 * Host: AsusFede * Database: C:\Users\Federico\AppData\Local\Temp\{94F7B7E4-58AC-4527-9A5A-DB3D525CAAA1}\ifc * Database version: 5507 * Database creation date: Thu Oct 05 23:02:58 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Oct 05 23:02:58 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 05 23:02:58 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, REF_LOTO01
LongName: LOTO 01 10+10+1.52

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identity Data - Organization Name: FARAONE SRL
Other - Category: Project Information; Project Issue Date: 18/09/2017; Project Name: LOTO 01 10+10+1.52; Project Number: REF_LOTO01

# IfcBuilding
Other - Category: Project Information; Project Issue Date: 18/09/2017; Project Name: LOTO 01 10+10+1.52; Project Number: REF_LOTO01
Identity Data - Organization Name: FARAONE SRL
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Livello 1
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: Livello 1; Family and Type: Level: Livello 1; Type: Level: Livello 1; Type Id: Level: Livello 1
Identity Data - Structural: no; Building Story: yes; Name: Livello 1
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm

# IfcCurtainWall: Curtain Wall:FAR_CW_CurtainWall_Loto01_LOD300, Curtain Wall:FAR_CW_CurtainWall_Loto01_LOD300:116235
In: Livello 1
Type - Construction(Type) - Automatically Embed: no; Curtain Panel: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; Function: Exterior; Join Condition: Vertical Grid Continuous
Type - Graphics(Type) - Fix_Point_Info_Img: Raster image: Info sistema.jpg; Image_Real: Raster image: Immagine reale.jpg (2); Profile_Image: Raster image: Immagine sistema.jpg (2)
Type - Horizontal Grid(Type) - Adjust for Mullion Size: yes; Layout: Fixed Distance; Spacing: 1800 mm
Type - Identity Data(Type) - Date of publishing: 18/09/2017; Description: AIR SYSTEM - LOTO; Manufacturer: Faraone srl - Architetture Trasparenti Via Po, 12 – 64018 Tortoreto Lido TE Tel. +39 0861 784200 – Fax +39 0861 781035 Partita IVA 00321830671 – faraone@faraone.it; Model: Loto 10+10+1,52; Type Comments: Air System is always made of stainless steel AISI 316 made by wax-waxed polishing process, polished and brushed to obtain a glossy finish. (satin finish on request); Type Name: FAR_CW_CurtainWall_Loto01_LOD300; URL: http://faraone.it/; Version: 2.0; Video_Youtube: https://www.youtube.com/user/Faraonesrl
Type - Other(Type) - Category: Walls; Family Name: Curtain Wall
Type - Structural Analysis(Type) - Load_Capacity_txt: Vertical= 4,85 KN Horizontal= 7,2 KN
Type - Vertical Grid(Type) - Adjust for Mullion Size: yes; Layout: Fixed Distance; Spacing: 1500 mm
Type - Vertical Mullions(Type) - Interior Type: Montante circolare: Mullion FARAONE_F01/A
Pset_CurtainWallCommon - Reference: Curtain Wall:FAR_CW_CurtainWall_Loto01_LOD300; IsExternal: yes
Pset_ManufacturerTypeInformation - Manufacturer: Faraone srl - Architetture Trasparenti Via Po, 12 – 64018 Tortoreto Lido TE Tel. +39 0861 784200 – Fax +39 0861 781035 Partita IVA 00321830671 – faraone@faraone.it
Constraints - Base Constraint: Level: Livello 1; Base is Attached: no; Base Offset: 0 mm; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 12600 mm
Dimensions - Area: 189 m2; Length: 15000 mm
Graphics - Profile_Assembly: Raster image: Assemblaggio profilo.jpg
Horizontal Grid - Angle: 0 deg; Justification: Beginning; Number: 6; Offset: 0 mm
Other - Category: Walls; Family: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family and Type: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Type: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Type Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300
Phasing - Phase Created: Nuova costruzione
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Vertical Grid - Angle: 0 deg; Justification: Beginning; Offset: 0 mm; Number: 9

# IfcMember: Curtain Wall:FAR_CW_CurtainWall_Loto01_LOD300:76957 (63)
In: Livello 1
PredefinedType: MULLION; Material: Alluminio, Argento anodizzato
Text(Type) - Mullion_Dimensions: 209 x 70 mm; Mullion_Max_Height: Valid for heights up to about 5.00 m. From 5.00 to 7.00 m with inner galvanized reinforcement 120x40; Mullion_Static_Info: Ix [mm^4] = 5862000 Iy [mm^4]= 939400 A [mm^2]= 1778
Other(Type) - Category: Curtain Wall Mullions; Family Name: Montante circolare
Materials and Finishes(Type) - Material: Alluminio, Argento anodizzato
Identity Data(Type) - Type Name: Mullion FARAONE_F01/A
Dimensions(Type) - Width on side 1: 0 mm; Width on side 2: 0 mm
Construction(Type) - Corner Mullion: no; Position: Perpendicular to Face; Profile: F01/A: F01/A; Thickness: 209 mm
Constraints(Type) - Angle: 0 deg; Offset: 30 mm
Constraints - Level: Level: Livello 1
Dimensions - Area: 0.430798 m2; Length: 1800 mm; Volume: 0.0206825 m3
Identity Data - Comments: 209 x 70 mm
Other - Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Category: Curtain Wall Mullions; Family: Montante circolare: Mullion FARAONE_F01/A; Family and Type: Montante circolare: Mullion FARAONE_F01/A; Type: Montante circolare: Mullion FARAONE_F01/A; Type Id: Montante circolare: Mullion FARAONE_F01/A
Phasing - Phase Created: Nuova costruzione
Pset_MemberCommon - IsExternal: yes; LoadBearing: yes; Reference: Montante circolare:Mullion FARAONE_F01/A; Span: 1800 mm

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B (8)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 5; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0549506 m3; Width: 1500 mm
Identity Data - Comments: E
Other - Category: Curtain Panels; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_B:...)
116238
116240
116242
116244
116246
116290
116298
116306

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL, G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL:116314
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 6; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0551148 m3; Width: 1500 mm
Identity Data - Comments: F
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BL; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR, G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR:116236
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 7; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0551148 m3; Width: 1500 mm
Other - Category: Curtain Panels; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_BR; LoadBearing: yes; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C (40)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; PredefinedType: CURTAIN_PANEL; Material: Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - Manufacturer: Faraone; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 1; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C
Type - Structural Analysis(Type) - Peso Max Vetro: 169291
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0551871 m3; Width: 1500 mm
Identity Data - Comments: A
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C; ThermalTransmittance: 2.103 kg/K/s3
Pset_ManufacturerTypeInformation - Manufacturer: Faraone
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_C:...)
116249
116250
116251
116252
116253
116291
116299
116307
116256
116257
116258
116259
116260
116292
116300
116308
116263
116264
116265
116266
116267
116293
116301
116309
116270
116271
116272
116273
116274
116294
116302
116310
116277
116278
116279
116280
116281
116295
116303
116311

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L (5)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L; PredefinedType: CURTAIN_PANEL; Material: Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 8; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L
Type - Materials and Finishes(Type) - Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0550731 m3; Width: 1500 mm
Identity Data - Comments: H
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_L:...)
116315
116316
116317
116318
116319

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R (5)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 9; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0550731 m3; Width: 1500 mm
Identity Data - Comments: I
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_R:...)
116248
116255
116262
116269
116276

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T (8)
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 2; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0549506 m3; Width: 1500 mm
Identity Data - Comments: B
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T; ThermalTransmittance: 2.103 kg/K/s3
Name (G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_T:...)
116284
116285
116286
116287
116288
116296
116304
116312

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL, G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL:116320
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 3; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0551202 m3; Width: 1500 mm
Identity Data - Comments: C
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TL; ThermalTransmittance: 2.103 kg/K/s3

# IfcPlate: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR, G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR:116283
In: Livello 1
Type - ElementType: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR; PredefinedType: CURTAIN_PANEL; Material: Alluminio, Argento anodizzato, Gomma, Silicone, Vetro, Vetratura trasparente, Temprato
Type - Analytical Properties(Type) - Analytic Construction: Doppi vetri basso-emissivi SC=0.6; Heat Transfer Coefficient (U): 2.103; Solar Heat Gain Coefficient: 0.6; Thermal Resistance (R): 0.475511; Visual Light Transmittance: 0.73
Type - Dimensions(Type) - Glass Thickness: 10 mm; Panel Lenght: 1500 mm; Space bt Glass: 1.6 mm
Type - Energy Analysis(Type) - Glass_Heat Transfer Coefficient (U): 5.3
Type - General(Type) - Glass_Max/Min_Tickness: 10/70 mm; Glass_Type: 10+10+1,52; Panel_Weight: 4.7938
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: 4; Type Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR
Type - Materials and Finishes(Type) - Aluminium: Alluminio, Argento anodizzato; Glass Material: Vetro, Vetratura trasparente, Temprato; Joint: Gomma, Silicone
Type - Other(Type) - Category: Curtain Panels; Family Name: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR
Constraints - Level: Level: Livello 1
Dimensions - Area: 2.7 m2; Height: 1800 mm; Volume: 0.0551148 m3; Width: 1500 mm
Identity Data - Comments: D
Other - Category: Curtain Panels; Host Id: Curtain Wall: FAR_CW_CurtainWall_Loto01_LOD300; Family: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR; Family and Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR; Type: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR; Type Id: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR
Phasing - Phase Created: Nuova costruzione
Pset_PlateCommon - IsExternal: yes; LoadBearing: yes; Reference: G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR:G257_Walls_Curtain-Cladding-Panels_FaraoneL01_TR; ThermalTransmittance: 2.103 kg/K/s3
